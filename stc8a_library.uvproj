# Keil uVision project stc8a_library.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc8a_library +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Core\Inc
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./Core/Src/: delay.c gpio.c iic.c uart.c exit.c timer.c encoder.c pid.c pwm.c jy901.c adc.c oled.c LMV358.c mpu6050.c
